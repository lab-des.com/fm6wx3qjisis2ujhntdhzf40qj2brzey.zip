Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-10-19T20:44:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Oct 19 20:44:32 2022 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{AE55AF75-CA41-4FC4-8836-228354C90B21}\ifc * Database version: 5507 * Database creation date: Wed Oct 19 20:44:32 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Oct 19 20:44:32 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Oct 19 20:44:32 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFurnishingElement: Abalon Table, Vitra-Sofas-Abalon_Table:Abalon Table:444004
In: Level 1
Type - Material: Deep black powder-coated (smooth), Table powder coating soft light
Type - Dimensions - NominalDepth: 900 mm; NominalHeight: 342 mm; NominalLength: 900 mm
Type - General - Author: BIMstone; BIMObjectName: Vitra-Sofas-Abalon_Table; ManufacturerName: Vitra; ManufacturerURL: https://www.vitra.com/; NBSDescription: Tables; NBSReference: 45-35-86/327; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_50_21_14; Uniclass2015Description: Coffee tables; Uniclass2015Reference: Pr_40_50_21_14; Version: 1; VersionDate: 28/09/2022
Type - Identity Data - Cost: 0; Description: The Abalon Sofa and Abalon Platform can be complemented with the Abalon Table from the same product family. The round tops of this coffee table are available in a choice of finishes.; Designer: Ronan & Erwan Bouroullec; Manufacturer: Vitra; Model: Abalon Table; OmniClass Number: 23.40.20.14.17.24; OmniClass Title: Coffee Tables; Type Name: Abalon Table; URL: https://www.vitra.com/living/product/details/abalon-table
Type - Other - Category: Furniture; AccessibilityPerformance: n/a; AssetType: Movable; Brand: Vitra; CodePerformance: n/a; Color: Various; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: Vitra-Sofas-Abalon_Table; Features: n/a; Finish: Table top: base material MDF (medium-density fibreboard) in real oak veneer or textured powder-coated finish; table thickness 25 mm with 15° bevelled edge. Base: non-swivel four-star base in die-cast aluminium, powder-coated finish, pedestal in steel, powder-coated finish. Glides: plastic glides for soft floors or felt glides for hard floors.; Grade: n/a; Material: Metal, wood; ModelNumber: n/a; ModelReference: n/a; Name: Abalon_Table; ReplacementCost: n/a; Shape: Sculptured; Size: Ø900x340 mm; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
Constraints - Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 1.4256 m2; Volume: 0.27702 m3
Materials and Finishes - BaseMaterial: Deep black powder-coated (smooth); TableTopMaterial: Table powder coating soft light
Other - AssetIdentifier: n/a; Barcode: n/a; Family: Vitra-Sofas-Abalon_Table: Abalon Table; Family and Type: Vitra-Sofas-Abalon_Table: Abalon Table; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: Vitra-Sofas-Abalon_Table: Abalon Table; Type Id: Vitra-Sofas-Abalon_Table: Abalon Table; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
